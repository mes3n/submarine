FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += " \
    file://mt7601u.cfg \
    file://ath9k_htc.cfg \
"
